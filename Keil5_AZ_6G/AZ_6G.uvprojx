# Keil uVision project AZ_6G.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: HC32L110C6PA HDSC
  pack: HDSC.HC32L110.1.0.3
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: AZ_6G
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
